# Keil uVision project i2c_new_interrupt.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C51 Microchip
  cpu: IRAM(0-0x7F) IROM(0-0xFFF) CLOCK(24000000)
  output: i2c_new_interrupt +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: eeprom.c main.c lcd1.c delay.c keypad.c header.h INT0.c edit_pass.c init_pass_read_eeprom.c init_pass_write_eeprom.c taking_id.c select_id.c welcome_Screen.c initialize_inturrupt.c motor.c enter_password.c system_block.c STARTUP.A51 compare_password.c
